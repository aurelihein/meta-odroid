FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

LINUX_VERSION ?= "5.0.19"
SRCREV ?= "3f7c1cab1a61108821cf47dda8a32ed25cc3588b"
SRCREV_meta ?= "2bc19ce252b1ce753056b32c55f55f515698b42a"

require linux-stable.inc
LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"
